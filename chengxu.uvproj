# Keil uVision project chengxu.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: chengxu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\IAP;.\UART
  group Source Group 1
    ./: STARTUP.A51 chengxu.c STC15W408AS.h
    ./IAP/: IAP.c
    ./UART/: uart.c
